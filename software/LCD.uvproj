# Keil uVision project LCD.uvproj, settings and files
target N76E003 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: n76e003 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  group user
    ./user/: common.c Delay.c font.c LCD.c main.c
