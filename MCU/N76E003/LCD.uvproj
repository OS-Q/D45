# Keil uVision project LCD.uvproj, settings and files
target qitas (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: ST7735 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  group user
    ./user/: main.c LCD.c font.c Delay.c common.c
