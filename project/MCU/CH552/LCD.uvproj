# Keil uVision project LCD.uvproj, settings and files
target qitas (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: headset +hex
  c flags: Optimize=6 SizeSpeed=1
  group user
    ./qitas/: common.c GPIO.c LCD.c main.c Timer.c USB.c
